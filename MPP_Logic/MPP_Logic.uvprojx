# Keil uVision project MPP_Logic.uvprojx, settings and files
target STM32F030R8T6 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MPP_Logic +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c include: .\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Driver\src;.\CMSIS\Device\ST\STM32F0xx\Include;.\STM32F0xx_StdPeriph_Driver;.\port;.\MAX31865;.\modbus\include;.\modbus;.\modbus\rtu;.\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: init_periph.c main.c init_periph.h
  group Modbus
    ./modbus/: mb.c
    ./modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ./modbus/ascii/: mbascii.c mbascii.h
    ./modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ./modbus/tcp/: mbtcp.c mbtcp.h
  group Periph
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./include/: stm32f0xx_conf.h
    ./CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h
  group Port
    ./port/: port.h portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.5.0
