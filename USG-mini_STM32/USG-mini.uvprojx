# Keil uVision project USG-mini.uvprojx, settings and files
target STM32F030K6 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: USG-mini +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c include: .\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source;.\User;.\STM32F0xx_StdPeriph_Driver;.\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./User/: main.c utilites.c handlers.c
    ./user/: periph_init.c terminal.c
  group Periph
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./STM32F0xx_StdPeriph_Driver/: stm32f0xx_conf.h
target STM32F030F4 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: USG-mini +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 3.40.0, Device:Startup 1.5.0
